# Keil uVision project Ultrasonic Ranging.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: Ultrasonic Ranging +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\SRC;.\SRC\oled;.\SRC\chao
  group Source Group 1
    ./: Ultrasonic Ranging.c
    ./SRC/: alarm.h temp.h
    ./SRC/oled/: oled.c
    ./SRC/chao/: chao.c
